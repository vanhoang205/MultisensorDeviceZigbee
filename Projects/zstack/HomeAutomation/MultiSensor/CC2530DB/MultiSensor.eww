<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MultiSensor.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>MultiSensor</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>MultiSensor</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>MultiSensor</project>
        <configuration>EndDeviceEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


